options:
  parameters:
    generate_options: qt_gui
    id: Zapojenie
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Excess_BW
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: Loop_Bandwidth
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: Samp_Symb
  id: variable
  parameters:
    value: '4'
  states: {}
- name: eq_mu
  id: variable
  parameters:
    value: '0.001'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rcc_tabs
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(Samp_Symb), Excess_BW, 11*Samp_Symb*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '0.0'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '336'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.1'
    seed: '0'
    taps: 1+0j
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_0
    differential: 'True'
    excess_bw: Excess_BW
    samples_per_symbol: Samp_Symb
    truncate: 'True'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: Loop_Bandwidth
    max_dev: '1.5'
    osps: '1'
    sps: Samp_Symb
    type: ccf
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import zmq
      import threading
      import time

      class blk(gr.sync_block):
          def __init__(self, example_param=None):
              gr.sync_block.__init__(self,
                  name="ZMQ TX Reference",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64])
              self._power   = 0.5
              self._running = False
              self._ctx     = None
              self._pub     = None

          def _start_zmq(self):
              self._running = True
              self._ctx = zmq.Context()
              self._pub = self._ctx.socket(zmq.PUB)
              self._pub.bind("tcp://127.0.0.1:5557")
              threading.Thread(target=self._metrics_loop, daemon=True).start()
              print("[GRC] ZMQ TX Reference start")

          def _metrics_loop(self):
              time.sleep(1.0)
              while self._running:
                  try:
                      self._pub.send_json({"tx_power": float(self._power)})
                  except Exception as e:
                      print(f"[GRC] tx ref err: {e}")
                  time.sleep(0.05)

          def work(self, input_items, output_items):
              if not self._running:
                  self._start_zmq()
              output_items[0][:] = input_items[0]
              self._power = float(np.mean(np.abs(input_items[0]) ** 2))
              return len(output_items[0])

          def stop(self):
              self._running = False
              if self._pub: self._pub.close()
              if self._ctx: self._ctx.term()
              print("[GRC] ZMQ TX Reference stop")
              return True
    example_param: '0'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import zmq
      import json
      import threading
      import time

      _gain  = 3.0    # štart s degradovaným stavom — agent to musí opraviť
      _phase = 0.0
      _eq_mu = 0.001

      BASE_SNR_DB = 20.0   # maximálne dosiahnuteľné SNR pri gain=1.0

      class blk(gr.sync_block):
          def __init__(self, example_param=None):
              gr.sync_block.__init__(self,
                  name="ZMQ Bridge",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64])
              self._power   = 0.5
              self._running = False
              self._ctx     = None
              self._rep     = None
              self._pub     = None

          def _start_zmq(self):
              self._running = True
              self._ctx = zmq.Context()
              self._rep = self._ctx.socket(zmq.REP)
              self._rep.setsockopt(zmq.RCVTIMEO, 100)
              self._rep.bind("tcp://127.0.0.1:5555")
              self._pub = self._ctx.socket(zmq.PUB)
              self._pub.bind("tcp://127.0.0.1:5556")
              threading.Thread(target=self._ctrl_loop,    daemon=True).start()
              threading.Thread(target=self._metrics_loop, daemon=True).start()
              print(f"[GRC] ZMQ Bridge štart — počiatočný gain={_gain}")

          def _ctrl_loop(self):
              global _gain, _phase, _eq_mu
              while self._running:
                  try:
                      raw  = self._rep.recv()
                      data = json.loads(raw.decode('utf-8'))
                      _gain  = float(np.clip(_gain  + data.get('gain',  0.0), 0.01, 5.0))
                      _phase = float(np.clip(_phase + data.get('phase', 0.0), -3.14, 3.14))
                      _eq_mu = float(np.clip(_eq_mu + data.get('eq_mu', 0.0), 0.0001, 0.1))
                      print(f"[GRC] gain={_gain:.3f} phase={_phase:.4f}")
                      self._rep.send(b'ok')
                  except zmq.Again:
                      pass
                  except Exception as e:
                      print(f"[GRC] ctrl err: {e}")
                      try:    self._rep.send(b'err')
                      except: pass

          def _metrics_loop(self):
              time.sleep(1.0)
              while self._running:
                  try:
                      # Jasná kvadratická SNR krivka centrovaná na gain=1.0
                      # gain=1.0 → SNR=20dB (optimum)
                      # gain=1.5 → SNR=16dB
                      # gain=2.0 → SNR= 5dB
                      # gain=3.0 → SNR= 0dB (štartovný stav — veľmi zlý)
                      # gain=0.5 → SNR=16dB
                      # gain=0.3 → SNR=11dB
                      snr_penalty = (_gain - 1.0) ** 2 * 15.0
                      snr = float(np.clip(
                          BASE_SNR_DB - snr_penalty + np.random.uniform(-0.3, 0.3),
                          0.0, 25.0
                      ))

                      pwr  = float(self._power)
                      rtt  = float(np.clip(50.0 + (20.0 - snr) * 8 + np.random.uniform(-2, 2), 20.0, 500.0))
                      loss = float(np.clip(0.4 - snr * 0.018 + np.random.uniform(-0.005, 0.005), 0.0, 1.0))
                      bler = float(np.clip(0.25 - snr * 0.009 + np.random.uniform(-0.003, 0.003), 0.0, 1.0))
                      tput = float(np.clip(snr * 0.5 + np.random.uniform(-0.3, 0.3), 0.0, 100.0))

                      self._pub.send_json({
                          "snr":        snr,
                          "power":      float(np.clip(pwr, 0.0, 10.0)),
                          "cfo":        0.0,
                          "throughput": tput,
                          "rtt":        rtt,
                          "loss":       loss,
                          "bler":       bler,
                          "gain":       _gain
                      })
                  except Exception as e:
                      print(f"[GRC] metrics err: {e}")
                  time.sleep(0.05)

          def work(self, input_items, output_items):
              if not self._running:
                  self._start_zmq()
              rot = np.exp(1j * _phase).astype(np.complex64)
              output_items[0][:] = (input_items[0] * np.float32(_gain) * rot)
              self._power = float(np.mean(np.abs(output_items[0]) ** 2))
              return len(output_items[0])

          def stop(self):
              self._running = False
              if self._rep: self._rep.close()
              if self._pub: self._pub.close()
              if self._ctx: self._ctx.term()
              print("[GRC] ZMQ Bridge stop")
              return True
    example_param: '0'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', blocks_char_to_float_0, '0']
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_char_to_float_1, '0', blocks_float_to_complex_1, '0']
- [blocks_float_to_complex_0, '0', epy_block_0, '0']
- [blocks_float_to_complex_1, '0', epy_block_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_rotator_cc_0, '0']
- [blocks_rotator_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', blocks_add_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_1, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [epy_block_0, '0', blocks_null_sink_1, '0']
- [epy_block_0_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
