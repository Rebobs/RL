options:
  parameters:
    generate_options: qt_gui
    id: Zapojenie
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Excess_BW
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: Loop_Bandwidth
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: Samp_Symb
  id: variable
  parameters:
    value: '4'
  states: {}
- name: amp_noise
  id: variable_qtgui_range
  parameters:
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.25'
  states: {}
- name: eq_mu
  id: variable
  parameters:
    value: '0.001'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: phase
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rcc_tabs
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(Samp_Symb), Excess_BW, 11*Samp_Symb*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tx_delay
  id: variable
  parameters:
    comment: TX path delay to align with RX chain
    value: '336'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: amp_noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_tx
  id: blocks_delay
  parameters:
    delay: tx_delay
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '0.0'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '336'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Embedded Python Block - Počet chýb, BER a počet bitov"""

          def __init__(self, processing=True):
              gr.sync_block.__init__(
                  self,
                  name='Errors-BER-Bits',
                  in_sig=[np.byte, np.byte], # → blok má 2 vstupy (napr. vyslaný a prijatý signál).
                  out_sig=[np.float32, np.float32, np.float32] # → má 3 výstupy (chyby, BER, celkové bity).
              )
              self.errors = 0
              self.total = 0
              self.processing = processing #– zapína/vypína spracovanie (ak False, blok nič nerobí)

          def work(self, input_items, output_items):
              if not self.processing:
                  return len(output_items[0])

              in0, in1 = input_items[0], input_items[1]
              length = min(len(in0), len(in1))

              # XOR bajtov a rozbalenie na bity
              xor_vals = np.bitwise_xor(in0[:length], in1[:length]).astype(np.uint8)
              bit_errors = np.unpackbits(xor_vals).sum()

              self.errors += bit_errors
              self.total += length * 8  # každý bajt = 8 bitov

              ber = (self.errors / self.total) if self.total > 0 else 0.0

              # Zapíš rovnakú hodnotu do celého výstupného poľa
              output_items[0][:] = self.errors
              output_items[1][:] = ber
              output_items[2][:] = self.total

              return len(output_items[0])
    processing: 'True'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import zmq
      import json
      import threading
      import time
      import collections
      import gc

      BER_WINDOW = 50

      class blk(gr.sync_block):
          def __init__(self, example_param=None):
              gr.sync_block.__init__(self,
                  name="ZMQ Bridge",
                  in_sig=[np.int8, np.int8],
                  out_sig=[np.int8, np.float32])
              self._running       = False
              self._ctx           = None
              self._rep           = None
              self._pub           = None
              self._noise_sigma   = 0.0
              self._win_errors    = 0
              self._win_total     = 0
              self._ber_window    = collections.deque(maxlen=BER_WINDOW)
              self._lock          = threading.Lock()
              self._top_block     = None

          def _find_top_block(self):
              for obj in gc.get_objects():
                  if type(obj).__name__ == 'Zapojenie':
                      return obj
              return None

          def _set_noise_amp(self, sigma):
              if self._top_block is None:
                  self._top_block = self._find_top_block()
              if self._top_block is not None:
                  try:
                      self._top_block.set_noise_amp(sigma)
                  except Exception as e:
                      print(f"[GRC] noise err: {e}")

          def _start_zmq(self):
              self._running = True
              self._ctx = zmq.Context()
              self._rep = self._ctx.socket(zmq.REP)
              self._rep.setsockopt(zmq.RCVTIMEO, 100)
              self._rep.bind("tcp://127.0.0.1:5555")
              self._pub = self._ctx.socket(zmq.PUB)
              self._pub.bind("tcp://127.0.0.1:5556")
              threading.Thread(target=self._ctrl_loop,    daemon=True).start()
              threading.Thread(target=self._metrics_loop, daemon=True).start()
              print("[GRC] Bridge ready — real BER (2-input sync)")

          def _ctrl_loop(self):
              while self._running:
                  try:
                      raw  = self._rep.recv()
                      data = json.loads(raw.decode())
                      new_sigma = float(np.clip(float(data.get("noise_sigma", self._noise_sigma)), 0.0, 5.0))
                      with self._lock:
                          self._noise_sigma = new_sigma
                      self._set_noise_amp(new_sigma)
                      self._rep.send(b"ok")
                  except zmq.Again:
                      pass
                  except Exception as e:
                      print(f"[GRC] ctrl err: {e}")
                      try: self._rep.send(b"err")
                      except: pass

          def _metrics_loop(self):
              time.sleep(1.0)
              while self._running:
                  try:
                      with self._lock:
                          bw    = list(self._ber_window)
                          sigma = self._noise_sigma
                      if bw:
                          ber_avg = float(np.clip(np.mean(bw), 1e-7, 1.0))
                          snr_db  = float(-20.0 * np.log10(max(sigma, 1e-6))) if sigma > 1e-6 else 40.0
                          snr_db  = float(np.clip(snr_db, -10.0, 40.0))
                          self._pub.send_json({"snr": snr_db, "ber": ber_avg, "noise_sigma": sigma})
                  except Exception as e:
                      print(f"[GRC] metrics err: {e}")
                  time.sleep(0.2)

          def work(self, input_items, output_items):
              if not self._running:
                  self._start_zmq()

              tx = input_items[0]
              rx = input_items[1]
              n  = len(tx)

              xor    = np.bitwise_xor(tx.view(np.uint8), rx.view(np.uint8))
              errors = int(np.unpackbits(xor).sum())

              with self._lock:
                  self._win_errors += errors
                  self._win_total  += n * 2
                  if self._win_total >= 2000:
                      ber = self._win_errors / self._win_total
                      self._ber_window.append(max(ber, 1e-7))
                      self._win_errors = 0
                      self._win_total  = 0
                  bw = list(self._ber_window)

              current_ber = float(np.clip(np.mean(bw), 1e-7, 1.0)) if bw else 1e-7

              output_items[0][:] = rx
              output_items[1][:] = current_ber
              return n

          def stop(self):
              self._running = False
              if self._rep: self._rep.close()
              if self._pub: self._pub.close()
              if self._ctx: self._ctx.term()
              return True
    example_param: '0'
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: GNURadio BER
    max: '0'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    color2: ("blue", "red")
    color3: ("black", "white")
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 1,0,1,1
    label1: Absolute Errors
    label2: My BER
    label3: Total Bits
    min: '0'
    name: '"Python BER"'
    nconnections: '3'
    type: float
    unit1: errors
    unit2: = X
    unit3: bits
  states: {}
- name: qtgui_number_sink_ber
  id: qtgui_number_sink
  parameters:
    avg: '0.5'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: BER (real-time)
    min: '0'
    name: '"Real BER"'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ZMQ_output
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ZMQ_output
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', blocks_char_to_float_0, '0']
- [analog_random_source_x_0, '0', blocks_delay_tx, '0']
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_random_source_x_0, '0', epy_block_0, '1']
- [analog_random_source_x_0, '0', fec_ber_bf_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_1, '0', blocks_float_to_complex_1, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_tx, '0', epy_block_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_null_sink_1, '0']
- [blocks_float_to_complex_1, '0', blocks_null_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_rotator_cc_0, '0']
- [blocks_rotator_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', epy_block_0_0, '1']
- [digital_constellation_encoder_bc_0, '0', blocks_throttle2_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0_0, '0']
- [epy_block_0, '1', qtgui_number_sink_0_0, '1']
- [epy_block_0, '2', qtgui_number_sink_0_0, '2']
- [epy_block_0_0, '0', blocks_char_to_float_1, '0']
- [epy_block_0_0, '0', virtual_sink_0, '0']
- [epy_block_0_0, '1', qtgui_number_sink_ber, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [virtual_source_0, '0', epy_block_0, '0']
- [virtual_source_0, '0', fec_ber_bf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
