options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: mpsk_stage6
    output_language: python
  states: {}

blocks:
- name: EbNo
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: EbNo
    rangeType: int
    start: '0'
    step: '1'
    stop: '20'
    value: '20'
  states: {}
- name: SNRdB
  id: variable
  parameters:
    value: (EbNo + 10*math.log(k,10) - 10*math.log(sps,10) )
  states: {}
- name: Sigma
  id: variable
  parameters:
    comment: varCh
    value: math.sqrt((1/pow(10,(SNRdB/10))))
  states: {}
- name: Sigma_varCh2
  id: variable
  parameters:
    comment: varCh/2
    value: math.sqrt((1/pow(10,(SNRdB/10)))/2)
  states: {}
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: Delay
    start: '0'
    step: '1'
    stop: '300'
    value: '14'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: k
  id: variable
  parameters:
    value: '2'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35,11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {state: disabled}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '100e-6'
    type: cma
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: Calculated SNR [dB]
    type: real
    value: SNRdB
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: Sigma_varCh2
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: byte
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: Sigma
    seed: '0'
    taps: 1+1j
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
    truncate: 'True'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '10000'
    type: '2'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Embedded Python Block - Počet chýb, BER a počet bitov"""

          def __init__(self, processing=True):
              gr.sync_block.__init__(
                  self,
                  name='Errors-BER-Bits',
                  in_sig=[np.byte, np.byte], # → blok má 2 vstupy (napr. vyslaný a prijatý signál).
                  out_sig=[np.float32, np.float32, np.float32] # → má 3 výstupy (chyby, BER, celkové bity).
              )
              self.errors = 0
              self.total = 0
              self.processing = processing #– zapína/vypína spracovanie (ak False, blok nič nerobí)

          def work(self, input_items, output_items):
              if not self.processing:
                  return len(output_items[0])

              in0, in1 = input_items[0], input_items[1]
              length = min(len(in0), len(in1))

              # XOR bajtov a rozbalenie na bity
              xor_vals = np.bitwise_xor(in0[:length], in1[:length]).astype(np.uint8)
              bit_errors = np.unpackbits(xor_vals).sum()

              self.errors += bit_errors
              self.total += length * 8  # každý bajt = 8 bitov

              ber = (self.errors / self.total) if self.total > 0 else 0.0

              # Zapíš rovnakú hodnotu do celého výstupného poľa
              output_items[0][:] = self.errors
              output_items[1][:] = ber
              output_items[2][:] = self.total

              return len(output_items[0])
    processing: 'True'
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'received@0: 0,0,1,1'
    label1: Using Linear Equalization Block
    name: '"Effect of using Linear Equalization Block - No Multipath Channel"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: GNURadio BER
    max: '0'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    color2: ("blue", "red")
    color3: ("black", "white")
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 1,0,1,1
    label1: Absolute Errors
    label2: My BER
    label3: Total Bits
    min: '0'
    name: '"Python BER"'
    nconnections: '3'
    type: float
    unit1: errors
    unit2: = X
    unit3: bits
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: RMS after channel model
    label2: RMS before channel model
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'received@1: 0,0,1,1'
    label1: Symbols
    name: ''
    size: '500'
    srate: samp_rate
    type: float
    ymax: '4'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    label1: Rx Bits
    label2: Tx Bits
    name: ''
    nconnections: '2'
    size: '500'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: black
    entags: 'False'
    grid: 'True'
    gui_hint: 4,1,1,1
    legend: 'False'
    name: '"Correct Delay Value"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    entags: 'False'
    grid: 'True'
    gui_hint: 4,0,1,1
    legend: 'False'
    name: '"Incorrect Delay Value"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation
    label1: Symbols
    num_tabs: '2'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:60002
    timeout: '100'
  states: {state: disabled}
- name: zeromq_push_msg_sink_0_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:60001
    timeout: '100'
  states: {state: disabled}
- name: zeromq_push_msg_sink_0_1
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:60000
    timeout: '100'
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [blocks_add_xx_0, '0', blocks_copy_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_delay_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_copy_0, '0', blocks_rms_xx_1, '0']
- [blocks_copy_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_copy_0, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_delay_0_0, '0', epy_block_0, '1']
- [blocks_delay_0_0, '0', fec_ber_bf_0, '1']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_1_0, '1']
- [blocks_nlog10_ff_0_0, '0', qtgui_number_sink_1_0, '0']
- [blocks_rms_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_rms_xx_1, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_throttle2_0, '0', blocks_rms_xx_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', epy_block_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_ber_bf_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_delay_0_0, '0']
- [channels_channel_model_0, '0', blocks_copy_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_1, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_1, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_probe_mpsk_snr_est_c_0, noise, zeromq_push_msg_sink_0, in]
- [digital_probe_mpsk_snr_est_c_0, signal, zeromq_push_msg_sink_0_0, in]
- [digital_probe_mpsk_snr_est_c_0, snr, zeromq_push_msg_sink_0_1, in]
- [epy_block_0, '0', qtgui_number_sink_0_0, '0']
- [epy_block_0, '1', qtgui_number_sink_0_0, '1']
- [epy_block_0, '2', qtgui_number_sink_0_0, '2']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
